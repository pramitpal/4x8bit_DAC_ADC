v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {miyahara_comparator.sym} -440 30 0 0 {name=x1}
C {devices/lab_pin.sym} -290 20 0 1 {name=p1 lab=VSS}
C {devices/lab_pin.sym} -290 0 0 1 {name=p2 lab=VCC}
C {devices/lab_pin.sym} -590 40 0 0 {name=p4 lab=VIP}
C {devices/lab_pin.sym} -590 0 0 0 {name=p5 lab=CLK}
C {devices/lab_pin.sym} -290 40 0 1 {name=p6 lab=OUTN}
C {devices/lab_pin.sym} -290 60 0 1 {name=p7 lab=OUTP}
C {devices/lab_pin.sym} -590 20 0 0 {name=p3 lab=VIN}
C {devices/lab_pin.sym} 230 70 0 1 {name=p12 lab=Q1}
C {devices/lab_pin.sym} 230 90 0 1 {name=p14 lab=QC1}
C {buf.sym} 80 60 0 0 {name=x3}
C {devices/lab_pin.sym} 230 50 0 1 {name=p13 lab=VSS}
C {devices/lab_pin.sym} 230 30 0 1 {name=p15 lab=VCC}
C {devices/lab_pin.sym} -70 30 0 0 {name=p16 lab=OUTN}
C {devices/lab_pin.sym} 230 170 0 1 {name=p8 lab=Q2}
C {devices/lab_pin.sym} 230 190 0 1 {name=p9 lab=QC2}
C {buf.sym} 80 160 0 0 {name=x2}
C {devices/lab_pin.sym} 230 150 0 1 {name=p10 lab=VSS}
C {devices/lab_pin.sym} 230 130 0 1 {name=p11 lab=VCC}
C {devices/lab_pin.sym} -70 130 0 0 {name=p17 lab=OUTP}
C {SR_latch.sym} 80 -70 0 0 {name=x4}
C {devices/lab_pin.sym} -70 -80 0 0 {name=p18 lab=Q1}
C {devices/lab_pin.sym} -70 -60 0 0 {name=p19 lab=Q2}
C {devices/lab_pin.sym} 230 -80 0 1 {name=p20 lab=VSS}
C {devices/lab_pin.sym} 230 -100 0 1 {name=p21 lab=VCC}
C {devices/lab_pin.sym} 230 -60 0 1 {name=p22 lab=Q}
C {devices/lab_pin.sym} 230 -40 0 1 {name=p23 lab=QC}
C {devices/iopin.sym} 390 -250 0 0 {name=p24 lab=VCC}
C {devices/ipin.sym} 410 -210 0 0 {name=p31 lab=CLK}
C {devices/opin.sym} 390 -150 0 0 {name=p32 lab=Q}
C {devices/opin.sym} 390 -130 0 0 {name=p33 lab=QC}
C {devices/ipin.sym} 410 -190 0 0 {name=p34 lab=VIN}
C {devices/ipin.sym} 410 -170 0 0 {name=p35 lab=VIP}
C {devices/iopin.sym} 390 -230 0 0 {name=p36 lab=VSS}
