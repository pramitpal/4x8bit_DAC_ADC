v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -20 270 0 0 {name=p4 lab=D0}
C {devices/ipin.sym} -20 290 0 0 {name=p1 lab=D1}
C {devices/ipin.sym} -20 310 0 0 {name=p2 lab=D2}
C {devices/ipin.sym} 470 160 0 0 {name=p3 lab=D3}
C {devices/ipin.sym} -20 60 0 0 {name=p5 lab=VREFH}
C {devices/ipin.sym} -20 330 0 0 {name=p6 lab=VREFL}
C {devices/opin.sym} 280 100 0 0 {name=p11 lab=D0_BUF}
C {devices/opin.sym} 280 120 0 0 {name=p8 lab=D1_BUF}
C {devices/opin.sym} 280 140 0 0 {name=p10 lab=D2_BUF}
C {devices/opin.sym} 770 180 0 0 {name=p12 lab=D3_BUF}
C {devices/opin.sym} 770 220 0 0 {name=p13 lab=VOUT}
C {devices/lab_pin.sym} 280 290 0 1 {name=p9 sig_type=std_logic lab=BUF0}
C {devices/lab_pin.sym} 280 310 0 1 {name=p20 sig_type=std_logic lab=BUF1}
C {devices/lab_pin.sym} 280 330 0 1 {name=p14 sig_type=std_logic lab=BUF2}
C {devices/lab_pin.sym} -20 80 0 0 {name=p15 sig_type=std_logic lab=BUF0}
C {devices/lab_pin.sym} -20 100 0 0 {name=p16 sig_type=std_logic lab=BUF1}
C {devices/lab_pin.sym} -20 120 0 0 {name=p17 sig_type=std_logic lab=BUF2}
C {devices/lab_pin.sym} -20 140 0 0 {name=p18 sig_type=std_logic lab=VINT}
C {devices/lab_pin.sym} -20 250 0 0 {name=p19 sig_type=std_logic lab=VINT}
C {devices/lab_pin.sym} 280 60 0 1 {name=p21 sig_type=std_logic lab=VCC}
C {devices/lab_pin.sym} 280 80 0 1 {name=p22 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 280 250 0 1 {name=p23 sig_type=std_logic lab=VCC}
C {devices/lab_pin.sym} 280 270 0 1 {name=p24 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 280 160 0 1 {name=p7 sig_type=std_logic lab=VINH}
C {devices/lab_pin.sym} 470 180 0 0 {name=p25 sig_type=std_logic lab=VINH}
C {devices/lab_pin.sym} 280 350 0 1 {name=p26 sig_type=std_logic lab=VINL}
C {devices/lab_pin.sym} 470 200 0 0 {name=p27 sig_type=std_logic lab=VINL}
C {devices/lab_pin.sym} 770 160 0 1 {name=p28 sig_type=std_logic lab=VCC}
C {devices/lab_pin.sym} 770 200 0 1 {name=p29 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 500 50 0 1 {name=p30 sig_type=std_logic lab=VCC}
C {devices/iopin.sym} 500 50 2 0 {name=p31 lab=VCC}
C {devices/lab_pin.sym} 500 80 0 1 {name=p32 sig_type=std_logic lab=VSS}
C {devices/iopin.sym} 500 80 2 0 {name=p33 lab=VSS}
C {/foss/designs/8_bit_dac/All_layouts/Layout_v2/lvs/All_schematic/3_bit_dac.sym} 130 130 0 0 {name=X1}
C {/foss/designs/8_bit_dac/All_layouts/Layout_v2/lvs/All_schematic/3_bit_dac.sym} 130 320 0 0 {name=X2}
C {/foss/designs/8_bit_dac/All_layouts/Layout_v2/lvs/All_schematic/switch_n_3v3.sym} 620 190 0 0 {name=x3}
