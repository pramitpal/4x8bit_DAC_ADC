v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/8_bit_dac/All_layouts/Layout_v2/lvs/z_stuff/All_schematic/8_bit_dac_tx_buffer.sym} 70 20 0 0 {name=x1}
C {/foss/designs/8_bit_dac/All_layouts/Layout_v2/lvs/z_stuff/All_schematic/8_bit_dac_tx_buffer.sym} 70 230 0 0 {name=x2}
C {/foss/designs/8_bit_dac/All_layouts/Layout_v2/lvs/z_stuff/All_schematic/8_bit_dac_tx_buffer.sym} 70 440 0 0 {name=x3}
C {/foss/designs/8_bit_dac/All_layouts/Layout_v2/lvs/z_stuff/All_schematic/8_bit_dac_tx_buffer.sym} 70 650 0 0 {name=x4}
C {devices/ipin.sym} 390 -70 0 0 {name=p1 lab=VREFH}
C {devices/opin.sym} 220 40 0 0 {name=p2 lab=VOUT0}
C {devices/iopin.sym} 370 -50 0 0 {name=p3 lab=VDDA}
C {devices/lab_pin.sym} -80 -60 0 0 {name=p4 sig_type=std_logic lab=VREFH}
C {devices/lab_pin.sym} -80 150 0 0 {name=p5 sig_type=std_logic lab=VREFH}
C {devices/lab_pin.sym} -80 360 0 0 {name=p6 sig_type=std_logic lab=VREFH}
C {devices/lab_pin.sym} -80 570 0 0 {name=p7 sig_type=std_logic lab=VREFH}
C {devices/ipin.sym} -80 -40 0 0 {name=p8 lab=Din0[0]}
C {devices/ipin.sym} -80 -20 0 0 {name=p9 lab=Din0[1]}
C {devices/ipin.sym} -80 0 0 0 {name=p10 lab=Din0[2]}
C {devices/ipin.sym} -80 20 0 0 {name=p11 lab=Din0[3]}
C {devices/ipin.sym} -80 40 0 0 {name=p12 lab=Din0[4]}
C {devices/ipin.sym} -80 60 0 0 {name=p13 lab=Din0[5]}
C {devices/ipin.sym} -80 80 0 0 {name=p14 lab=Din0[6]}
C {devices/ipin.sym} -80 100 0 0 {name=p15 lab=Din0[7]}
C {devices/ipin.sym} -80 170 0 0 {name=p16 lab=Din1[0]}
C {devices/ipin.sym} -80 190 0 0 {name=p17 lab=Din1[1]}
C {devices/ipin.sym} -80 210 0 0 {name=p18 lab=Din1[2]}
C {devices/ipin.sym} -80 230 0 0 {name=p19 lab=Din1[3]}
C {devices/ipin.sym} -80 250 0 0 {name=p20 lab=Din1[4]}
C {devices/ipin.sym} -80 270 0 0 {name=p21 lab=Din1[5]}
C {devices/ipin.sym} -80 290 0 0 {name=p22 lab=Din1[6]}
C {devices/ipin.sym} -80 310 0 0 {name=p23 lab=Din1[7]}
C {devices/ipin.sym} -80 380 0 0 {name=p24 lab=Din2[0]}
C {devices/ipin.sym} -80 400 0 0 {name=p25 lab=Din2[1]}
C {devices/ipin.sym} -80 420 0 0 {name=p26 lab=Din2[2]}
C {devices/ipin.sym} -80 440 0 0 {name=p27 lab=Din2[3]}
C {devices/ipin.sym} -80 460 0 0 {name=p28 lab=Din2[4]}
C {devices/ipin.sym} -80 480 0 0 {name=p29 lab=Din2[5]}
C {devices/ipin.sym} -80 500 0 0 {name=p30 lab=Din2[6]}
C {devices/ipin.sym} -80 520 0 0 {name=p31 lab=Din2[7]}
C {devices/ipin.sym} -80 590 0 0 {name=p32 lab=Din3[0]}
C {devices/ipin.sym} -80 610 0 0 {name=p33 lab=Din3[1]}
C {devices/ipin.sym} -80 630 0 0 {name=p34 lab=Din3[2]}
C {devices/ipin.sym} -80 650 0 0 {name=p35 lab=Din3[3]}
C {devices/ipin.sym} -80 670 0 0 {name=p36 lab=Din3[4]}
C {devices/ipin.sym} -80 690 0 0 {name=p37 lab=Din3[5]}
C {devices/ipin.sym} -80 710 0 0 {name=p38 lab=Din3[6]}
C {devices/ipin.sym} -80 730 0 0 {name=p39 lab=Din3[7]}
C {devices/lab_pin.sym} 220 -60 0 1 {name=p40 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 220 -40 0 1 {name=p41 sig_type=std_logic lab=VSSA}
C {devices/lab_pin.sym} 220 -20 0 1 {name=p42 sig_type=std_logic lab=VCCD}
C {devices/lab_pin.sym} 220 0 0 1 {name=p43 sig_type=std_logic lab=VSSD}
C {devices/lab_pin.sym} 220 150 0 1 {name=p44 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 220 170 0 1 {name=p45 sig_type=std_logic lab=VSSA}
C {devices/lab_pin.sym} 220 190 0 1 {name=p46 sig_type=std_logic lab=VCCD}
C {devices/lab_pin.sym} 220 210 0 1 {name=p47 sig_type=std_logic lab=VSSD}
C {devices/lab_pin.sym} 220 360 0 1 {name=p48 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 220 380 0 1 {name=p49 sig_type=std_logic lab=VSSA}
C {devices/lab_pin.sym} 220 400 0 1 {name=p50 sig_type=std_logic lab=VCCD}
C {devices/lab_pin.sym} 220 420 0 1 {name=p51 sig_type=std_logic lab=VSSD}
C {devices/lab_pin.sym} 220 570 0 1 {name=p52 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 220 590 0 1 {name=p53 sig_type=std_logic lab=VSSA}
C {devices/lab_pin.sym} 220 610 0 1 {name=p54 sig_type=std_logic lab=VCCD}
C {devices/lab_pin.sym} 220 630 0 1 {name=p55 sig_type=std_logic lab=VSSD}
C {devices/opin.sym} 220 250 0 0 {name=p56 lab=VOUT1}
C {devices/opin.sym} 220 460 0 0 {name=p57 lab=VOUT2}
C {devices/opin.sym} 220 670 0 0 {name=p58 lab=VOUT3}
C {devices/iopin.sym} 370 -30 0 0 {name=p59 lab=VSSA}
C {devices/iopin.sym} 370 -10 0 0 {name=p60 lab=VCCD}
C {devices/iopin.sym} 370 10 0 0 {name=p61 lab=VSSD}
