v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/8_bit_dac/All_layouts/Layout_v2/lvs/z_stuff/All_schematic/4x8_bit_dac.sym} 0 80 0 0 {name=x1}
C {devices/lab_pin.sym} -150 -240 0 0 {name=p4 sig_type=std_logic lab=VREFH}
C {devices/ipin.sym} -150 -220 0 0 {name=p8 lab=Din0[0]}
C {devices/ipin.sym} -150 -200 0 0 {name=p9 lab=Din0[1]}
C {devices/ipin.sym} -150 -180 0 0 {name=p10 lab=Din0[2]}
C {devices/ipin.sym} -150 -160 0 0 {name=p11 lab=Din0[3]}
C {devices/ipin.sym} -150 -140 0 0 {name=p12 lab=Din0[4]}
C {devices/ipin.sym} -150 -120 0 0 {name=p13 lab=Din0[5]}
C {devices/ipin.sym} -150 -100 0 0 {name=p14 lab=Din0[6]}
C {devices/ipin.sym} -150 -80 0 0 {name=p15 lab=Din0[7]}
C {devices/ipin.sym} -150 -60 0 0 {name=p16 lab=Din1[0]}
C {devices/ipin.sym} -150 -40 0 0 {name=p17 lab=Din1[1]}
C {devices/ipin.sym} -150 -20 0 0 {name=p18 lab=Din1[2]}
C {devices/ipin.sym} -150 0 0 0 {name=p19 lab=Din1[3]}
C {devices/ipin.sym} -150 20 0 0 {name=p20 lab=Din1[4]}
C {devices/ipin.sym} -150 40 0 0 {name=p21 lab=Din1[5]}
C {devices/ipin.sym} -150 60 0 0 {name=p22 lab=Din1[6]}
C {devices/ipin.sym} -150 80 0 0 {name=p23 lab=Din1[7]}
C {devices/ipin.sym} -150 100 0 0 {name=p24 lab=Din2[0]}
C {devices/ipin.sym} -150 120 0 0 {name=p25 lab=Din2[1]}
C {devices/ipin.sym} -150 140 0 0 {name=p26 lab=Din2[2]}
C {devices/ipin.sym} -150 160 0 0 {name=p27 lab=Din2[3]}
C {devices/ipin.sym} -150 180 0 0 {name=p28 lab=Din2[4]}
C {devices/ipin.sym} -150 200 0 0 {name=p29 lab=Din2[5]}
C {devices/ipin.sym} -150 220 0 0 {name=p30 lab=Din2[6]}
C {devices/ipin.sym} -150 240 0 0 {name=p31 lab=Din2[7]}
C {devices/ipin.sym} -150 260 0 0 {name=p32 lab=Din3[0]}
C {devices/ipin.sym} -150 280 0 0 {name=p33 lab=Din3[1]}
C {devices/ipin.sym} -150 300 0 0 {name=p34 lab=Din3[2]}
C {devices/ipin.sym} -150 320 0 0 {name=p35 lab=Din3[3]}
C {devices/ipin.sym} -150 340 0 0 {name=p36 lab=Din3[4]}
C {devices/ipin.sym} -150 360 0 0 {name=p37 lab=Din3[5]}
C {devices/ipin.sym} -150 380 0 0 {name=p38 lab=Din3[6]}
C {devices/ipin.sym} -150 400 0 0 {name=p39 lab=Din3[7]}
C {devices/ipin.sym} 240 -20 0 0 {name=p2 lab=VREFH}
C {devices/iopin.sym} 220 0 0 0 {name=p3 lab=VDDA}
C {devices/iopin.sym} 220 20 0 0 {name=p59 lab=VSSA}
C {devices/iopin.sym} 220 40 0 0 {name=p60 lab=VCCD}
C {devices/iopin.sym} 220 60 0 0 {name=p61 lab=VSSD}
C {devices/opin.sym} 150 -160 0 0 {name=p1 lab=VOUT0}
C {devices/opin.sym} 150 -140 0 0 {name=p56 lab=VOUT1}
C {devices/opin.sym} 150 -120 0 0 {name=p57 lab=VOUT2}
C {devices/opin.sym} 150 -100 0 0 {name=p58 lab=VOUT3}
C {devices/lab_pin.sym} 150 -240 0 1 {name=p40 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 150 -220 0 1 {name=p41 sig_type=std_logic lab=VSSA}
C {devices/lab_pin.sym} 150 -200 0 1 {name=p42 sig_type=std_logic lab=VCCD}
C {devices/lab_pin.sym} 150 -180 0 1 {name=p43 sig_type=std_logic lab=VSSD}
