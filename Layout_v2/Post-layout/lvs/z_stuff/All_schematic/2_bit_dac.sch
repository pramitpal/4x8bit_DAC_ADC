v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -230 10 0 0 {name=p4 lab=D1}
C {devices/ipin.sym} -700 0 0 0 {name=p5 lab=D0}
C {devices/opin.sym} -400 20 0 0 {name=p6 lab=D0_BUF}
C {devices/opin.sym} 70 30 0 0 {name=p7 lab=D1_BUF}
C {devices/opin.sym} 70 70 0 0 {name=p8 lab=VOUT}
C {devices/ipin.sym} -700 40 0 0 {name=p9 lab=VREFL}
C {devices/ipin.sym} -700 20 0 0 {name=p10 lab=VREFH}
C {devices/lab_pin.sym} -400 0 0 1 {name=p1 sig_type=std_logic lab=VCC}
C {devices/lab_pin.sym} -400 40 0 1 {name=p2 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -300 -90 0 1 {name=p3 sig_type=std_logic lab=VCC}
C {devices/iopin.sym} -300 -90 2 0 {name=p13 lab=VCC}
C {devices/lab_pin.sym} -300 -60 0 1 {name=p14 sig_type=std_logic lab=VSS}
C {devices/iopin.sym} -300 -60 2 0 {name=p15 lab=VSS}
C {devices/lab_pin.sym} 70 10 0 1 {name=p11 sig_type=std_logic lab=VCC}
C {devices/lab_pin.sym} 70 50 0 1 {name=p12 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -400 60 0 1 {name=p16 sig_type=std_logic lab=VINL}
C {devices/lab_pin.sym} -400 80 0 1 {name=p17 sig_type=std_logic lab=VINH}
C {devices/lab_pin.sym} -230 30 0 0 {name=p18 sig_type=std_logic lab=VINH}
C {devices/lab_pin.sym} -230 50 0 0 {name=p19 sig_type=std_logic lab=VINL}
C {switch2n_3v3.sym} -550 40 0 0 {name=x1}
C {switch_n_3v3.sym} -80 40 0 0 {name=x2}
