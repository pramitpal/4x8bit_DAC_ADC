v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -20 350 0 0 {name=p4 lab=D0}
C {devices/ipin.sym} -20 370 0 0 {name=p1 lab=D1}
C {devices/ipin.sym} -20 390 0 0 {name=p2 lab=D2}
C {devices/ipin.sym} 470 200 0 0 {name=p3 lab=D7}
C {devices/ipin.sym} -20 10 0 0 {name=p5 lab=VREFH}
C {devices/ipin.sym} -20 490 0 0 {name=p6 lab=VREFL}
C {devices/opin.sym} 280 50 0 0 {name=p11 lab=D0_BUF}
C {devices/opin.sym} 280 70 0 0 {name=p8 lab=D1_BUF}
C {devices/opin.sym} 280 90 0 0 {name=p10 lab=D2_BUF}
C {devices/opin.sym} 770 220 0 0 {name=p12 lab=D7_BUF}
C {devices/opin.sym} 770 260 0 0 {name=p13 lab=VOUT}
C {devices/lab_pin.sym} 280 370 0 1 {name=p9 sig_type=std_logic lab=BUF0}
C {devices/lab_pin.sym} 280 390 0 1 {name=p20 sig_type=std_logic lab=BUF1}
C {devices/lab_pin.sym} 280 410 0 1 {name=p14 sig_type=std_logic lab=BUF2}
C {devices/lab_pin.sym} -20 30 0 0 {name=p15 sig_type=std_logic lab=BUF0}
C {devices/lab_pin.sym} -20 50 0 0 {name=p16 sig_type=std_logic lab=BUF1}
C {devices/lab_pin.sym} -20 70 0 0 {name=p17 sig_type=std_logic lab=BUF2}
C {devices/lab_pin.sym} -20 170 0 0 {name=p18 sig_type=std_logic lab=VINT}
C {devices/lab_pin.sym} -20 330 0 0 {name=p19 sig_type=std_logic lab=VINT}
C {devices/lab_pin.sym} 280 10 0 1 {name=p21 sig_type=std_logic lab=VCC}
C {devices/lab_pin.sym} 280 30 0 1 {name=p22 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 280 330 0 1 {name=p23 sig_type=std_logic lab=VCC}
C {devices/lab_pin.sym} 280 350 0 1 {name=p24 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 280 190 0 1 {name=p7 sig_type=std_logic lab=VINH}
C {devices/lab_pin.sym} 470 220 0 0 {name=p25 sig_type=std_logic lab=VINH}
C {devices/lab_pin.sym} 280 510 0 1 {name=p26 sig_type=std_logic lab=VINL}
C {devices/lab_pin.sym} 470 240 0 0 {name=p27 sig_type=std_logic lab=VINL}
C {devices/lab_pin.sym} 770 200 0 1 {name=p28 sig_type=std_logic lab=VCC}
C {devices/lab_pin.sym} 770 240 0 1 {name=p29 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 500 0 0 1 {name=p30 sig_type=std_logic lab=VCC}
C {devices/iopin.sym} 500 0 2 0 {name=p31 lab=VCC}
C {devices/lab_pin.sym} 500 30 0 1 {name=p32 sig_type=std_logic lab=VSS}
C {devices/iopin.sym} 500 30 2 0 {name=p33 lab=VSS}
C {devices/lab_pin.sym} -20 90 0 0 {name=p34 sig_type=std_logic lab=BUF3}
C {devices/ipin.sym} -20 410 0 0 {name=p35 lab=D3}
C {devices/lab_pin.sym} 280 430 0 1 {name=p36 sig_type=std_logic lab=BUF3}
C {devices/opin.sym} 280 110 0 0 {name=p37 lab=D3_BUF}
C {devices/lab_pin.sym} -20 110 0 0 {name=p38 sig_type=std_logic lab=BUF4}
C {devices/lab_pin.sym} 280 450 0 1 {name=p39 sig_type=std_logic lab=BUF4}
C {devices/ipin.sym} -20 430 0 0 {name=p40 lab=D4}
C {devices/opin.sym} 280 130 0 0 {name=p41 lab=D4_BUF}
C {devices/lab_pin.sym} -20 130 0 0 {name=p42 sig_type=std_logic lab=BUF5}
C {devices/ipin.sym} -20 450 0 0 {name=p43 lab=D5}
C {devices/lab_pin.sym} 280 470 0 1 {name=p44 sig_type=std_logic lab=BUF5}
C {devices/opin.sym} 280 150 0 0 {name=p45 lab=D5_BUF}
C {devices/lab_pin.sym} -20 150 0 0 {name=p46 sig_type=std_logic lab=BUF6}
C {devices/opin.sym} 280 170 0 0 {name=p47 lab=D6_BUF}
C {devices/ipin.sym} -20 470 0 0 {name=p48 lab=D6}
C {devices/lab_pin.sym} 280 490 0 1 {name=p49 sig_type=std_logic lab=BUF6}
C {/foss/designs/8_bit_dac/All_layouts/Layout_v2/lvs/All_schematic/7_bit_dac.sym} 130 100 0 0 {name=x1}
C {/foss/designs/8_bit_dac/All_layouts/Layout_v2/lvs/All_schematic/7_bit_dac.sym} 130 420 0 0 {name=x2}
C {/foss/designs/8_bit_dac/All_layouts/Layout_v2/lvs/All_schematic/switch_n_3v3.sym} 620 230 0 0 {name=x3}
