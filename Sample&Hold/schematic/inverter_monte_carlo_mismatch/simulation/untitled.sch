v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/device_param_probe.sym} 60 -30 0 0 {name=r1
devicename=M1
devicemodel=nfet_01v8
deviceparam=gm
}
C {devices/vsource.sym} -30 -65 0 0 {name=V2 value=1.8}
